<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8_NFC_TAG.ewp</path>
  </project>
  <batchBuild/>
</workspace>


