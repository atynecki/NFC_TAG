<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>inc</name>
    <file>
      <name>$PROJ_DIR$\inc\app_manager.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\hardware_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\LCD_driver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\lib_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\M24Lr04E-R_driver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\inc\STTS751_driver.h</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\src\app_manager.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\hardware_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\it_handlers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\LCD_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\M24LR04E-R_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\STTS751_driver.c</name>
    </file>
  </group>
</project>


